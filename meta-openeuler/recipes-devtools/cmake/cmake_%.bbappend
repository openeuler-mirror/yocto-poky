require cmake-src.inc

